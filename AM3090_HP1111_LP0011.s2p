! Date/Time: Thu, Feb 28, 2019 2:09 PM
! Network Analyzer: Agilent Technologies E8364B Rev: A.07.50.67
! Sweep from 0.010 to 30.000 GHz, 1601 Points, Sweep Type: LOG
! Power Supply: 5.022 V, 0.002 A
# Hz S DB R 50
!freq MagS11 AngS11 MagS21 AngS21 MagS12 AngS12 MagS22 AngS22
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 30 GHz, reference 50 ohm
!   highest |S21| = -33.79 dB at 2.169 GHz (marker M1); lowest = -71.0 dB at 6.855 GHz (marker M2)
!   lowest |S11| = -12.6 dB at 6.424 GHz (marker M3), VSWR 1.61, Z = 35.5 + j14.1 ohm
!   |S11| at or under -10 dB: 1.624 GHz to 2.4 GHz (775.4 MHz wide, 38.5 % of centre); 3.206 GHz to 3.443 GHz (237.5 MHz wide, 7.14 % of centre); 5.885 GHz to 6.756 GHz (870.7 MHz wide, 13.8 % of centre) (the widest 3 of 4)
!   |S22| runs from -13.3 to -0.2 dB; largest |S21 - S12| = 0.016
!   the Smith chart shows 4.37 GHz to 7.966 GHz only
!   S11 on the Smith chart (normalised r, x): 4.37 GHz: 0.37, +1.08; 5.18 GHz: 3.60, -1.39; 6.234 GHz: 0.64, -0.25; 6.719 GHz: 1.44, -0.59; 7.243 GHz: 0.33, +0.13; 7.966 GHz: 1.82, +1.30
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.2  -43.2  -38.9  -0.5
! 38.04 MHz  -0.2  -42.6  -42.1  -1.1
! 95.05 MHz  -0.8  -39.7  -39.6  -2.9
! 144.7 MHz  -1.7  -56.3  -56.2  -5.9
! 182.2 MHz  -4.7  -57.7  -59.2  -12.9
! 205.4 MHz  -9.3  -34.1  -33.9  -8.4
! 239.9 MHz  -9.4  -57.5  -56.8  -1.2
! 550.5 MHz  -2.1  -41.8  -41.7  -0.3
! 2.084 GHz  -11.1  -34.3  -34.3  -1.0
! 2.169 GHz  -11.0  -33.8  -33.8  -1.2
! 4.37 GHz  -2.9  -67.1  -62.5  -0.7
! 5.18 GHz  -4.2  -63.1  -63.7  -0.8
! 6.234 GHz  -11.7  -62.8  -66.0  -0.6
! 6.424 GHz  -12.6  -65.5  -66.1  -0.6
! 6.719 GHz  -10.6  -69.9  -66.1  -0.6
! 6.855 GHz  -7.8  -71.0  -66.6  -0.6
! 7.243 GHz  -5.8  -67.7  -64.1  -0.6
! 7.926 GHz  -6.2  -64.1  -62.6  -0.7
! 7.966 GHz  -6.1  -64.5  -62.5  -0.7
! 16.21 GHz  -2.6  -63.6  -65.8  -1.7
! 23.48 GHz  -3.4  -42.6  -42.8  -2.9
! 30 GHz  -2.8  -57.2  -54.1  -2.2

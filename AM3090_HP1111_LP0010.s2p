! Date/Time: Thu, Feb 28, 2019 2:09 PM
! Network Analyzer: Agilent Technologies E8364B Rev: A.07.50.67
! Sweep from 0.010 to 30.000 GHz, 1601 Points, Sweep Type: LOG
! Power Supply: 5.022 V, 0.002 A
# Hz S DB R 50
!freq MagS11 AngS11 MagS21 AngS21 MagS12 AngS12 MagS22 AngS22
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 30 GHz, reference 50 ohm
!   highest |S21| = -32.42 dB at 2.158 GHz (marker M1); lowest = -70.1 dB at 4.805 GHz (marker M2)
!   lowest |S11| = -12.6 dB at 6.424 GHz (marker M3), VSWR 1.61, Z = 35.4 + j14.2 ohm
!   |S11| at or under -10 dB: 1.619 GHz to 2.398 GHz (779.9 MHz wide, 38.8 % of centre); 3.207 GHz to 3.441 GHz (234.6 MHz wide, 7.06 % of centre); 5.886 GHz to 6.755 GHz (869.1 MHz wide, 13.8 % of centre) (the widest 3 of 4)
!   |S22| runs from -13.4 to -0.2 dB; largest |S21 - S12| = 0.011
!   the Smith chart shows 4.37 GHz to 7.966 GHz only
!   S11 on the Smith chart (normalised r, x): 4.37 GHz: 0.36, +1.08; 5.18 GHz: 3.60, -1.40; 6.234 GHz: 0.64, -0.25; 6.719 GHz: 1.44, -0.60; 7.243 GHz: 0.33, +0.13; 7.966 GHz: 1.82, +1.31
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.3  -48.4  -38.7  -0.6
! 38.04 MHz  -0.3  -42.0  -41.7  -1.1
! 106.6 MHz  -1.0  -40.6  -40.7  -3.8
! 144.7 MHz  -1.7  -57.3  -55.7  -6.1
! 182.2 MHz  -4.7  -57.5  -60.4  -13.3
! 203.4 MHz  -9.0  -41.1  -41.0  -7.4
! 550.5 MHz  -2.1  -40.7  -40.9  -0.2
! 2.084 GHz  -11.2  -32.9  -32.9  -1.0
! 2.158 GHz  -11.1  -32.4  -32.4  -1.3
! 4.37 GHz  -2.8  -66.0  -64.9  -0.7
! 4.805 GHz  -2.6  -70.1  -64.2  -0.7
! 5.18 GHz  -4.2  -64.5  -62.5  -0.8
! 6.234 GHz  -11.7  -64.6  -63.4  -0.6
! 6.424 GHz  -12.6  -64.7  -63.1  -0.6
! 6.719 GHz  -10.6  -66.3  -65.6  -0.6
! 7.243 GHz  -5.8  -65.6  -67.3  -0.6
! 7.926 GHz  -6.2  -63.2  -64.6  -0.7
! 7.966 GHz  -6.1  -63.4  -65.1  -0.7
! 10.65 GHz  -3.3  -52.6  -52.8  -1.6
! 16.05 GHz  -2.7  -64.1  -65.8  -1.7
! 23.59 GHz  -3.5  -42.6  -42.4  -2.7
! 30 GHz  -2.8  -56.9  -59.1  -2.2

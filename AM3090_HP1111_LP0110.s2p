! Date/Time: Thu, Feb 28, 2019 2:10 PM
! Network Analyzer: Agilent Technologies E8364B Rev: A.07.50.67
! Sweep from 0.010 to 30.000 GHz, 1601 Points, Sweep Type: LOG
! Power Supply: 5.022 V, 0.002 A
# Hz S DB R 50
!freq MagS11 AngS11 MagS21 AngS21 MagS12 AngS12 MagS22 AngS22
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 30 GHz, reference 50 ohm
!   highest |S21| = -13.91 dB at 218.1 MHz (marker M1); lowest = -68.4 dB at 6.924 GHz (marker M2)
!   lowest |S11| = -12.8 dB at 231.6 MHz (marker M3), VSWR 1.60, Z = 33.5 - j9.93 ohm
!   |S11| at or under -10 dB: 206.9 MHz to 244.9 MHz (37.95 MHz wide, 16.8 % of centre); 1.67 GHz to 2.361 GHz (691.3 MHz wide, 34.3 % of centre); 5.885 GHz to 6.756 GHz (870.8 MHz wide, 13.8 % of centre)
!   |S22| runs from -14.0 to -0.2 dB; largest |S21 - S12| = 0.014
!   the Smith chart shows 164.8 MHz to 315.9 MHz only
!   S11 on the Smith chart (normalised r, x): 164.8 MHz: 0.19, -0.47; 195.4 MHz: 0.51, +0.48; 222.5 MHz: 1.06, -0.55; 248.4 MHz: 1.31, +0.87; 274.6 MHz: 0.68, -1.22; 315.9 MHz: 0.41, +0.06
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.3  -46.1  -45.6  -0.6
! 38.04 MHz  -0.3  -41.9  -42.4  -1.1
! 104 MHz  -0.9  -40.4  -40.5  -3.3
! 144.7 MHz  -1.7  -55.7  -55.8  -5.4
! 164.8 MHz  -2.7  -59.5  -56.1  -7.1
! 182.2 MHz  -4.7  -57.3  -59.5  -10.2
! 195.4 MHz  -7.3  -39.8  -38.9  -11.9
! 218.1 MHz  -11.4  -13.9  -13.9  -13.5
! 222.5 MHz  -11.7  -14.7  -14.7  -11.9
! 231.6 MHz  -12.8  -20.9  -20.9  -7.6
! 248.4 MHz  -8.5  -42.1  -41.9  -2.4
! 274.6 MHz  -4.3  -55.7  -56.9  -1.1
! 315.9 MHz  -7.4  -56.0  -58.4  -0.6
! 550.5 MHz  -2.1  -49.2  -48.6  -0.3
! 2.084 GHz  -10.9  -46.6  -46.6  -0.7
! 3.253 GHz  -8.9  -66.9  -64.3  -6.4
! 6.924 GHz  -6.8  -68.4  -64.9  -0.6
! 7.926 GHz  -6.2  -64.8  -64.5  -0.7
! 10.59 GHz  -3.3  -53.0  -53.1  -1.5
! 20.2 GHz  -9.1  -62.5  -59.2  -4.7
! 23.48 GHz  -3.5  -42.9  -42.6  -2.9
! 30 GHz  -2.8  -60.3  -56.7  -2.3

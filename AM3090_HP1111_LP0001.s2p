! Date/Time: Thu, Feb 28, 2019 2:09 PM
! Network Analyzer: Agilent Technologies E8364B Rev: A.07.50.67
! Sweep from 0.010 to 30.000 GHz, 1601 Points, Sweep Type: LOG
! Power Supply: 5.022 V, 0.002 A
# Hz S DB R 50
!freq MagS11 AngS11 MagS21 AngS21 MagS12 AngS12 MagS22 AngS22
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 30 GHz, reference 50 ohm
!   highest |S21| = -29.59 dB at 2.136 GHz (marker M1); lowest = -68.8 dB at 4.878 GHz (marker M2)
!   lowest |S11| = -12.6 dB at 6.424 GHz (marker M3), VSWR 1.61, Z = 35.5 + j14.2 ohm
!   |S11| at or under -10 dB: 1.609 GHz to 2.388 GHz (778.2 MHz wide, 38.9 % of centre); 3.188 GHz to 3.456 GHz (268.6 MHz wide, 8.08 % of centre); 5.886 GHz to 6.755 GHz (869.4 MHz wide, 13.8 % of centre) (the widest 3 of 4)
!   |S22| runs from -15.2 to -0.1 dB; largest |S21 - S12| = 0.017
!   the Smith chart shows 4.37 GHz to 7.966 GHz only
!   S11 on the Smith chart (normalised r, x): 4.37 GHz: 0.36, +1.08; 5.18 GHz: 3.59, -1.40; 6.234 GHz: 0.64, -0.25; 6.719 GHz: 1.44, -0.60; 7.243 GHz: 0.33, +0.13; 7.966 GHz: 1.83, +1.31
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.3  -39.4  -42.1  -0.5
! 38.04 MHz  -0.3  -42.2  -41.8  -1.1
! 102.5 MHz  -0.9  -40.1  -40.2  -3.6
! 144.7 MHz  -1.7  -54.3  -55.7  -6.4
! 550.5 MHz  -2.2  -39.0  -39.0  -0.2
! 2.084 GHz  -11.4  -29.9  -29.9  -1.2
! 2.136 GHz  -11.5  -29.6  -29.6  -1.4
! 3.172 GHz  -9.7  -58.2  -60.1  -9.5
! 4.37 GHz  -2.8  -66.4  -63.3  -0.7
! 4.878 GHz  -3.0  -68.8  -68.7  -0.8
! 5.18 GHz  -4.2  -67.3  -65.7  -0.8
! 6.234 GHz  -11.7  -64.8  -63.8  -0.6
! 6.424 GHz  -12.6  -64.7  -63.7  -0.6
! 6.719 GHz  -10.6  -66.6  -67.5  -0.6
! 7.243 GHz  -5.8  -67.3  -67.7  -0.6
! 7.926 GHz  -6.2  -65.1  -63.4  -0.7
! 7.966 GHz  -6.1  -65.4  -63.6  -0.8
! 10.65 GHz  -3.3  -53.6  -53.4  -1.5
! 12.01 GHz  -4.3  -66.3  -64.7  -2.0
! 20.2 GHz  -9.1  -61.7  -60.6  -4.7
! 23.48 GHz  -3.5  -43.0  -42.3  -2.9
! 30 GHz  -2.8  -53.1  -56.2  -2.1

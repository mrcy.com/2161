! Date/Time: Thu, Feb 28, 2019 2:09 PM
! Network Analyzer: Agilent Technologies E8364B Rev: A.07.50.67
! Sweep from 0.010 to 30.000 GHz, 1601 Points, Sweep Type: LOG
! Power Supply: 5.022 V, 0.002 A
# Hz S DB R 50
!freq MagS11 AngS11 MagS21 AngS21 MagS12 AngS12 MagS22 AngS22
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 30 GHz, reference 50 ohm
!   highest |S21| = -28.40 dB at 2.136 GHz (marker M1); lowest = -68.6 dB at 4.805 GHz (marker M2)
!   lowest |S11| = -12.6 dB at 6.424 GHz (marker M3), VSWR 1.61, Z = 35.5 + j14.1 ohm
!   |S11| at or under -10 dB: 1.605 GHz to 2.383 GHz (778 MHz wide, 39 % of centre); 3.191 GHz to 3.456 GHz (264.8 MHz wide, 7.97 % of centre); 5.885 GHz to 6.756 GHz (870.9 MHz wide, 13.8 % of centre) (the widest 3 of 4)
!   |S22| runs from -15.2 to -0.1 dB; largest |S21 - S12| = 0.012
!   the Smith chart shows 4.37 GHz to 7.966 GHz only
!   S11 on the Smith chart (normalised r, x): 4.37 GHz: 0.37, +1.08; 5.18 GHz: 3.59, -1.40; 6.234 GHz: 0.64, -0.25; 6.719 GHz: 1.44, -0.59; 7.243 GHz: 0.33, +0.13; 7.966 GHz: 1.82, +1.30
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.3  -43.6  -52.6  -0.6
! 38.04 MHz  -0.2  -42.3  -41.6  -1.0
! 106.6 MHz  -1.0  -40.9  -40.7  -4.0
! 144.7 MHz  -1.7  -60.6  -56.0  -6.8
! 227 MHz  -11.9  -54.7  -52.8  -1.1
! 550.5 MHz  -2.2  -38.3  -38.4  -0.2
! 2.084 GHz  -11.7  -28.7  -28.7  -1.2
! 2.136 GHz  -11.8  -28.4  -28.4  -1.5
! 4.37 GHz  -2.9  -65.5  -65.9  -0.7
! 4.805 GHz  -2.6  -68.6  -66.7  -0.7
! 5.18 GHz  -4.2  -64.7  -63.4  -0.8
! 6.234 GHz  -11.7  -64.2  -62.8  -0.6
! 6.424 GHz  -12.6  -64.1  -63.3  -0.6
! 6.719 GHz  -10.6  -66.4  -73.0  -0.6
! 7.243 GHz  -5.8  -64.6  -74.9  -0.6
! 7.926 GHz  -6.2  -64.2  -66.5  -0.8
! 7.966 GHz  -6.1  -64.0  -66.1  -0.8
! 10.59 GHz  -3.3  -53.5  -53.6  -1.5
! 12.07 GHz  -4.3  -64.7  -66.4  -2.2
! 20.1 GHz  -9.1  -59.6  -61.1  -4.5
! 23.48 GHz  -3.5  -42.7  -42.5  -2.9
! 30 GHz  -2.9  -56.2  -54.9  -2.2

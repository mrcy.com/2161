! Date/Time: Thu, Feb 28, 2019 2:10 PM
! Network Analyzer: Agilent Technologies E8364B Rev: A.07.50.67
! Sweep from 0.010 to 30.000 GHz, 1601 Points, Sweep Type: LOG
! Power Supply: 5.023 V, 0.002 A
# Hz S DB R 50
!freq MagS11 AngS11 MagS21 AngS21 MagS12 AngS12 MagS22 AngS22
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 30 GHz, reference 50 ohm
!   highest |S21| = -11.99 dB at 221.4 MHz (marker M1); lowest = -69.0 dB at 4.64 GHz (marker M2)
!   lowest |S11| = -14.6 dB at 233.9 MHz (marker M3), VSWR 1.46, Z = 35.9 - j7.46 ohm
!   |S11| at or under -10 dB: 206.4 MHz to 248.4 MHz (41.99 MHz wide, 18.5 % of centre); 1.678 GHz to 2.348 GHz (670 MHz wide, 33.3 % of centre); 5.884 GHz to 6.755 GHz (871.1 MHz wide, 13.8 % of centre)
!   |S22| runs from -15.0 to -0.2 dB; largest |S21 - S12| = 0.013
!   the Smith chart shows 164 MHz to 322.3 MHz only
!   S11 on the Smith chart (normalised r, x): 164 MHz: 0.19, -0.49; 195.4 MHz: 0.51, +0.48; 222.5 MHz: 1.09, -0.51; 253.4 MHz: 1.81, +0.94; 280.1 MHz: 0.56, -1.05; 322.3 MHz: 0.42, +0.16
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.3  -42.8  -44.1  -0.6
! 38.04 MHz  -0.3  -42.3  -42.1  -1.2
! 99.92 MHz  -0.9  -40.1  -40.0  -2.9
! 144.7 MHz  -1.7  -58.3  -54.7  -5.4
! 164 MHz  -2.7  -58.8  -56.2  -6.6
! 180.3 MHz  -4.4  -58.9  -59.5  -9.3
! 195.4 MHz  -7.3  -38.3  -40.5  -11.9
! 221.4 MHz  -12.1  -12.0  -11.9  -14.0
! 222.5 MHz  -12.3  -12.0  -12.0  -13.8
! 233.9 MHz  -14.6  -16.3  -16.2  -9.5
! 253.4 MHz  -7.5  -38.1  -38.7  -2.6
! 280.1 MHz  -4.3  -60.0  -59.9  -1.1
! 322.3 MHz  -7.5  -60.6  -60.1  -0.5
! 550.5 MHz  -2.1  -51.1  -50.5  -0.3
! 2.084 GHz  -10.9  -49.2  -48.7  -0.7
! 2.558 GHz  -9.1  -40.7  -40.6  -1.3
! 3.172 GHz  -8.4  -64.6  -62.2  -5.3
! 4.64 GHz  -2.4  -69.0  -65.2  -0.7
! 7.926 GHz  -6.2  -63.7  -63.0  -0.8
! 20.2 GHz  -9.2  -61.7  -59.5  -4.7
! 23.36 GHz  -3.4  -42.7  -42.5  -3.0
! 30 GHz  -2.9  -55.5  -55.0  -2.2

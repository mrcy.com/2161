! Date/Time: Thu, Feb 28, 2019 2:08 PM
! Network Analyzer: Agilent Technologies E8364B Rev: A.07.50.67
! Sweep from 0.010 to 30.000 GHz, 1601 Points, Sweep Type: LOG
! Power Supply: 5.022 V, 0.002 A
# Hz S DB R 50
!freq MagS11 AngS11 MagS21 AngS21 MagS12 AngS12 MagS22 AngS22
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 30 GHz, reference 50 ohm
!   highest |S21| = -11.45 dB at 177.7 MHz (marker M1); lowest = -66.9 dB at 4.525 GHz (marker M2)
!   lowest |S11| = -15.0 dB at 6.328 GHz (marker M3), VSWR 1.43, Z = 35 - j2.2 ohm
!   |S11| at or under -10 dB: 1.61 GHz to 2.387 GHz (777.2 MHz wide, 38.9 % of centre); 3.184 GHz to 3.465 GHz (280.8 MHz wide, 8.45 % of centre); 5.93 GHz to 6.722 GHz (791.2 MHz wide, 12.5 % of centre) (the widest 3 of 4)
!   |S22| runs from -23.7 to -0.1 dB; largest |S21 - S12| = 0.013
!   the Smith chart shows 4.48 GHz to 7.691 GHz only
!   S11 on the Smith chart (normalised r, x): 4.48 GHz: 0.42, +1.29; 5.232 GHz: 3.23, -3.48; 5.841 GHz: 0.45, -0.49; 6.686 GHz: 1.82, +0.27; 7.1 GHz: 0.36, -0.24; 7.691 GHz: 0.75, +0.89
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.2  -41.6  -41.7  -0.6
! 38.04 MHz  -0.3  -50.7  -52.6  -1.1
! 98.93 MHz  -1.4  -57.0  -55.7  -4.2
! 144.7 MHz  -4.5  -49.1  -49.8  -8.9
! 177.7 MHz  -12.1  -11.4  -11.4  -23.0
! 221.4 MHz  -5.0  -58.0  -56.4  -1.4
! 550.5 MHz  -2.1  -39.1  -39.2  -0.2
! 2.084 GHz  -11.5  -30.0  -30.0  -1.2
! 3.172 GHz  -9.8  -58.4  -59.2  -9.5
! 4.48 GHz  -2.7  -66.6  -63.6  -0.6
! 4.525 GHz  -2.6  -66.9  -64.6  -0.6
! 5.232 GHz  -2.4  -65.4  -64.8  -0.8
! 5.841 GHz  -6.3  -65.9  -63.8  -0.7
! 6.328 GHz  -15.0  -64.0  -67.1  -0.6
! 6.686 GHz  -10.3  -62.5  -63.1  -0.6
! 7.1 GHz  -6.1  -61.8  -62.5  -0.6
! 7.691 GHz  -6.5  -61.0  -61.8  -0.7
! 7.926 GHz  -6.3  -60.4  -60.6  -0.7
! 15.97 GHz  -2.7  -63.7  -65.0  -1.8
! 20.72 GHz  -9.3  -61.0  -61.1  -5.2
! 23.36 GHz  -3.4  -42.7  -42.8  -3.0
! 30 GHz  -2.9  -56.8  -56.5  -2.2

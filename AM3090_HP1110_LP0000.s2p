! Date/Time: Thu, Feb 28, 2019 2:08 PM
! Network Analyzer: Agilent Technologies E8364B Rev: A.07.50.67
! Sweep from 0.010 to 30.000 GHz, 1601 Points, Sweep Type: LOG
! Power Supply: 5.023 V, 0.002 A
# Hz S DB R 50
!freq MagS11 AngS11 MagS21 AngS21 MagS12 AngS12 MagS22 AngS22
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 30 GHz, reference 50 ohm
!   highest |S21| = -12.48 dB at 175.9 MHz (marker M1); lowest = -67.1 dB at 4.617 GHz (marker M2)
!   lowest |S11| = -15.0 dB at 6.328 GHz (marker M3), VSWR 1.44, Z = 35 - j2.19 ohm
!   |S11| at or under -10 dB: 1.605 GHz to 2.383 GHz (778.2 MHz wide, 39 % of centre); 3.186 GHz to 3.465 GHz (279.4 MHz wide, 8.4 % of centre); 5.93 GHz to 6.722 GHz (791.3 MHz wide, 12.5 % of centre) (the widest 3 of 4)
!   |S22| runs from -21.7 to -0.1 dB; largest |S21 - S12| = 0.011
!   the Smith chart shows 4.48 GHz to 7.691 GHz only
!   S11 on the Smith chart (normalised r, x): 4.48 GHz: 0.42, +1.29; 5.232 GHz: 3.24, -3.49; 5.841 GHz: 0.45, -0.49; 6.686 GHz: 1.82, +0.27; 7.1 GHz: 0.36, -0.25; 7.691 GHz: 0.75, +0.89
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.2  -44.8  -43.7  -0.5
! 38.04 MHz  -0.3  -52.3  -50.8  -1.0
! 144.7 MHz  -4.5  -49.2  -49.4  -9.3
! 175.9 MHz  -12.1  -12.5  -12.4  -21.3
! 217 MHz  -5.8  -52.2  -52.9  -1.5
! 550.5 MHz  -2.1  -38.6  -38.5  -0.2
! 2.084 GHz  -11.6  -28.7  -28.6  -1.3
! 3.204 GHz  -10.3  -58.8  -58.1  -9.6
! 4.48 GHz  -2.7  -65.9  -61.6  -0.6
! 4.617 GHz  -2.5  -67.1  -62.5  -0.7
! 5.232 GHz  -2.4  -66.0  -65.5  -0.8
! 5.841 GHz  -6.3  -64.6  -64.7  -0.7
! 6.328 GHz  -15.0  -65.9  -64.5  -0.6
! 6.686 GHz  -10.3  -63.1  -62.3  -0.6
! 7.1 GHz  -6.0  -61.5  -62.3  -0.6
! 7.691 GHz  -6.5  -61.6  -62.9  -0.7
! 7.926 GHz  -6.3  -60.6  -61.8  -0.8
! 13.54 GHz  -9.2  -55.0  -54.3  -2.0
! 16.13 GHz  -2.7  -65.2  -64.3  -1.7
! 20.61 GHz  -9.3  -61.0  -58.6  -5.0
! 23.48 GHz  -3.5  -42.7  -42.5  -2.9
! 30 GHz  -2.9  -53.4  -57.6  -2.2

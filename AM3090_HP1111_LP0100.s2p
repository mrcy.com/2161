! Date/Time: Thu, Feb 28, 2019 2:10 PM
! Network Analyzer: Agilent Technologies E8364B Rev: A.07.50.67
! Sweep from 0.010 to 30.000 GHz, 1601 Points, Sweep Type: LOG
! Power Supply: 5.022 V, 0.002 A
# Hz S DB R 50
!freq MagS11 AngS11 MagS21 AngS21 MagS12 AngS12 MagS22 AngS22
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 30 GHz, reference 50 ohm
!   highest |S21| = -22.88 dB at 210.6 MHz (marker M1); lowest = -69.7 dB at 6.821 GHz (marker M2)
!   lowest |S11| = -12.6 dB at 6.424 GHz (marker M3), VSWR 1.61, Z = 35.4 + j14.1 ohm
!   |S11| at or under -10 dB: 218.9 MHz to 239.2 MHz (20.35 MHz wide, 8.89 % of centre); 1.65 GHz to 2.391 GHz (741.3 MHz wide, 36.7 % of centre); 5.885 GHz to 6.755 GHz (869.5 MHz wide, 13.8 % of centre) (the widest 3 of 4)
!   |S22| runs from -13.2 to -0.1 dB; largest |S21 - S12| = 0.013
!   the Smith chart shows 4.37 GHz to 7.966 GHz only
!   S11 on the Smith chart (normalised r, x): 4.37 GHz: 0.36, +1.08; 5.18 GHz: 3.59, -1.40; 6.234 GHz: 0.64, -0.25; 6.719 GHz: 1.44, -0.60; 7.243 GHz: 0.33, +0.13; 7.966 GHz: 1.83, +1.31
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.2  -45.8  -40.9  -0.5
! 38.04 MHz  -0.3  -42.2  -42.0  -1.1
! 106.6 MHz  -1.0  -40.9  -40.4  -3.6
! 144.7 MHz  -1.7  -56.9  -57.6  -5.6
! 182.2 MHz  -4.7  -57.3  -56.4  -11.5
! 210.6 MHz  -10.0  -22.9  -22.8  -10.5
! 242.3 MHz  -9.0  -55.7  -56.9  -1.5
! 270.5 MHz  -4.4  -59.0  -57.8  -0.7
! 550.5 MHz  -2.1  -44.3  -44.2  -0.2
! 2.084 GHz  -10.8  -40.4  -40.2  -0.8
! 4.37 GHz  -2.8  -67.0  -65.5  -0.7
! 5.18 GHz  -4.2  -64.2  -62.8  -0.8
! 6.234 GHz  -11.7  -63.5  -65.5  -0.6
! 6.424 GHz  -12.6  -65.5  -65.6  -0.6
! 6.719 GHz  -10.6  -68.9  -66.8  -0.6
! 6.821 GHz  -8.5  -69.7  -67.4  -0.6
! 7.243 GHz  -5.8  -65.5  -67.0  -0.6
! 7.926 GHz  -6.2  -64.4  -63.1  -0.7
! 7.966 GHz  -6.1  -65.2  -63.1  -0.8
! 16.37 GHz  -2.6  -63.6  -62.3  -1.8
! 23.48 GHz  -3.5  -42.9  -42.5  -2.9
! 30 GHz  -2.9  -53.4  -53.8  -2.2

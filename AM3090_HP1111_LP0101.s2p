! Date/Time: Thu, Feb 28, 2019 2:10 PM
! Network Analyzer: Agilent Technologies E8364B Rev: A.07.50.67
! Sweep from 0.010 to 30.000 GHz, 1601 Points, Sweep Type: LOG
! Power Supply: 5.022 V, 0.002 A
# Hz S DB R 50
!freq MagS11 AngS11 MagS21 AngS21 MagS12 AngS12 MagS22 AngS22
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 30 GHz, reference 50 ohm
!   highest |S21| = -18.65 dB at 212.7 MHz (marker M1); lowest = -70.6 dB at 4.687 GHz (marker M2)
!   lowest |S11| = -12.6 dB at 6.424 GHz (marker M3), VSWR 1.61, Z = 35.4 + j14.2 ohm
!   |S11| at or under -10 dB: 207.8 MHz to 240.1 MHz (32.33 MHz wide, 14.4 % of centre); 1.657 GHz to 2.378 GHz (721.4 MHz wide, 35.8 % of centre); 5.886 GHz to 6.755 GHz (869.4 MHz wide, 13.8 % of centre)
!   |S22| runs from -13.3 to -0.2 dB; largest |S21 - S12| = 0.014
!   the Smith chart shows 4.391 GHz to 7.966 GHz only
!   S11 on the Smith chart (normalised r, x): 4.391 GHz: 0.38, +1.13; 5.206 GHz: 3.36, -1.57; 6.234 GHz: 0.64, -0.25; 6.719 GHz: 1.44, -0.60; 7.243 GHz: 0.33, +0.13; 7.966 GHz: 1.83, +1.30
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.3  -40.5  -42.3  -0.6
! 38.04 MHz  -0.3  -42.4  -42.1  -1.1
! 106.6 MHz  -1.0  -40.1  -41.0  -3.5
! 144.7 MHz  -1.7  -57.2  -55.8  -5.5
! 182.2 MHz  -4.7  -58.0  -56.9  -10.8
! 212.7 MHz  -10.4  -18.6  -18.6  -11.8
! 259.9 MHz  -4.7  -60.1  -61.5  -1.0
! 550.5 MHz  -2.1  -45.5  -45.7  -0.2
! 2.084 GHz  -10.8  -42.2  -42.4  -0.8
! 4.391 GHz  -2.8  -65.4  -64.9  -0.7
! 4.687 GHz  -2.4  -70.6  -67.7  -0.7
! 5.206 GHz  -4.3  -63.7  -63.6  -0.8
! 6.234 GHz  -11.6  -64.5  -62.0  -0.6
! 6.424 GHz  -12.6  -66.1  -64.4  -0.6
! 6.719 GHz  -10.6  -67.3  -67.6  -0.6
! 7.243 GHz  -5.8  -65.8  -68.0  -0.6
! 7.926 GHz  -6.2  -64.1  -67.6  -0.7
! 7.966 GHz  -6.1  -64.3  -66.8  -0.7
! 10.59 GHz  -3.3  -54.6  -54.2  -1.4
! 20.72 GHz  -9.3  -59.4  -61.6  -5.2
! 23.48 GHz  -3.4  -42.6  -42.8  -2.9
! 30 GHz  -2.9  -60.3  -56.7  -2.1
